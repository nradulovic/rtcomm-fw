# Keil uVision project teslameter_3mhx_fw.uvprojx, settings and files
target 3mhx_teslameter (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: teslameter_3mhx_fw +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_HAL_DRIVER,USE_USB_FS
  c include: ./application/environment/hal;./application/environment/neon;./application/include;./cmsis/include;./cmsis/device/st/stm32f4xx/include;./hal/include;./neon/lib/include/lib;./neon/eds/include;./neon/eds/port/stm32f4xx-none-arm;./lib/STM32_USB_Device_Library/Core/Inc;./lib/STM32_USB_Device_Library/Class/CDC/Inc;./neon/lib/include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\application\environment\linker\SHW_3MH6_F411.sct
  group Enviorenment
    ./application/environment/startup/arm/: startup_stm32f411xe.s
  group HAL_lib
    ./hal/source/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group USB_core
    ./lib/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./lib/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Neon
    ./neon/eds/source/: epa.c equeue.c etimer.c event.c heap.c mem.c pool.c sched.c smp.c static.c stdheap.c timer.c deferred.c
    ./neon/lib/source/: bits.c checksum.c
    ./neon/eds/port/stm32f4xx-none-arm/: p_core.c
    ./neon/lib/source/string/: num_conv.c
  group Application
    ./application/source/: acq_channels.c acq_sync.c ads1256.c app_stat.c aux_channels.c bsp.c ctrl_bus.c data_process.c device_mem_map.c epa_acq.c epa_adt7410.c epa_aux.c epa_eeprom.c epa_heartbeat.c epa_i2c.c epa_main.c epa_protocol.c epa_tft.c epa_acq_interface.c main.c ms_bus.c notify.c nv_data.c ppbuff.c prim_spi.c support.c trigger.c app_gui.c epa_calibration.c
  group USB-HAL_conf
    ./application/environment/hal/: stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_system.c
    ./application/source/: usbd_cdc_if.c usbd_conf.c usbd_desc.c
